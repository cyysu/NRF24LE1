# Keil uVision project uart_led.uvproj, settings and files
target UART_LED (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODDP2
  output: uart_led +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: hal\nrf24le1;hal;compiler\c51;compiler\common
  group application
    ./: main.c
  group hal
    ./hal/nrf24le1/: hal_clk.c hal_uart.c
