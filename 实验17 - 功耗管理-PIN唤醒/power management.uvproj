# Keil uVision project power management.uvproj, settings and files
target power management (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODDP2
  output: power management +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: hal\nrf24le1;hal;hal\nrf24l01p;compiler\common;compiler\c51
  group application
    ./: main.c
  group hal
    ./hal/: hal_delay.c
    ./hal/nrf24le1/: hal_clk.c hal_rtc.c hal_uart.c
