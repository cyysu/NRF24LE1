# Keil uVision project oled.uvproj, settings and files
target OLED (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODDP2
  output: oled +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: compiler\common;hal\nrf24le1;hal;hal\nrf24l01p;compiler\c51
  group application
    ./: main.c
  group hal
    ./hal/: hal_delay.c
  group oled
    ./: oled.c oledfont.c
